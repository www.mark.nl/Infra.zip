Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2017-11-01T15:45:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 01 15:45:42 2017 * Host: B3ROBRAWR3331 * Database: C:\Users\RVI\AppData\Local\Temp\{FB68C552-7F60-4B57-915A-CA7499BE3E76}\ifc * Database version: 5507 * Database creation date: Wed Nov 01 15:45:39 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Nov 01 15:45:39 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 01 15:45:39 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcSpaceHeater: INFRA 50-12, HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN:INFRA 50-12:1300111
In: V00
Type - PredefinedType: CONVECTOR; Material: Color RGB - 193-193-194
Type - Dimensions - Diameter 1: 100 mm; Diameter 2: 100 mm; Length: 12200 mm; Width: 600 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: Waterproof stainless steel Infra; Article Type: INFRA 50-12; Content Supplier URL: www.mepcontent.eu; Copyright: © Trimble Europe BV; Custom: no; Description: Waterproof stainless steel Infra; EMCS Version: 3.0; ETIM Article Class: EC000535; Family Version: 11.06; GTIN: 87193332511500; Manufacturer: Mark; Manufacturer Art. No.: 5025115; Manufacturer URL: http://www.markclimate.com/radiant-heating/gas-fired/infra/; MEPcontent Class: RADIANT_HEATER; Model: INFRA 50-12; OmniClass Number: 23.75.70.17.17; OmniClass Title: Radiation Panels; Product Line: Mark; Revit Version: 2018; Type Name: INFRA 50-12; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Grey: Color RGB - 193-193-194
Type - Mechanical - Heating Power: 485452
Type - Other - Category: Mechanical Equipment; Bend Length: 310 mm; Bend Socket Length: 80 mm; Body Length: 2935 mm; Body Thickness: 10 mm; Connections Offset: 80 mm; Default Height: 172 mm; Family Name: HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN; Fifth Bracket: 2400 mm; First Bracket: 575 mm; Fourth Bracket: 2885 mm; Front Connection Length: 214 mm; Front Revolve Offset: 144 mm; Half Diameter 1: 50 mm; Half Diameter 2: 50 mm; Left Reference Line Length: 1467.5 mm; Rear Revolve Offset: 146 mm; Revolve Void Offset: 15 mm; Right Reference Line Length: 10732.5 mm; Safe Height: 172 mm; Safe Length: 12200 mm; Safe Width: 600 mm; Second Bracket: 2910 mm; Third Bracket: 2895 mm; Void Body Length: 2915 mm; Void Body Width: 580 mm
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Angle: 0 deg; Area: 13.7605 m2; Height: 400 mm; Volume: 0.231382 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Exhaust Air,Power,Supply Air
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Angle Formula: 0 mm; Angle Safe: 0 deg; Family: HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN: INFRA 50-12; Family and Type: HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN: INFRA 50-12; Height Safe: 400 mm; Pendant Height: 90 mm; Pendant Length: 17.75 mm; Pendant Length 2: 0 mm; Pump Length: 505 mm; Second Pendant Length: 42 mm; Second Pendant Length 2: 24 mm; Type: HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN: INFRA 50-12; Type Id: HC_Radiant Heater_MEPcontent_Mark_Infra_INT-EN: INFRA 50-12; Void Angle: 1 deg; Void Height: 250 mm
Phasing - Phase Created: 4. Plan over 10 jaar
